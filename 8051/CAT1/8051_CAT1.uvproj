# Keil uVision project 8051_CAT1.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 8051_CAT1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ledblink.c STARTUP.A51
